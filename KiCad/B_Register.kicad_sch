File: KiCad/B_Register.kicad_sch (KiCad schematic)
At the start: 22 parts, among them U15 74LS245, U16 74LS173, U17 74LS173

Commit message: Updates
Parts:
- gave numbers to parts that had none: 1
